Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2024-02-20T08:17:41
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 20 08:17:41 2024 * Host: DEGTL11901 * Database: C:\Users\deschvi\AppData\Local\Temp\ca8c1f2c-9901-4390-8e33-b9644a3a5d49\cfd740ed-981c-4fd1-895d-5808a80cab12\ifc * Database version: 5507 * Database creation date: Tue Feb 20 08:17:37 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Feb 20 08:17:37 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 20 08:17:37 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12529780_KZ_DAD4841_MASW:28D4841M_KZ_12529780_DAD4841_MASW, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 28D4841M_KZ_12529780_DAD4841_MASW
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 28D4841M_KZ_12529780_DAD4841_MASW
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_OBSW, z_Miele_Design_Zinc_Steel, Výchozí Nový materiál, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 936 mm; Height: 730 mm; Depth: 170 mm

# IfcDistributionPort, Port_351014
Description: Flow; FlowDirection: SOURCEANDSINK
